Commit message: Fixed box error

File: models/soccerbot/model.urdf (robot description, URDF)
Before this commit: robot soccerbot_noarms, 22 links, 21 joints
Links:
- link left_foot: geometry collision box size=0.05 0.05 0.02; collision box size=0.05 0.05 0.02
